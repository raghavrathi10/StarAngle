options:
  parameters:
    author: raghav
    generate_options: qt_gui
    id: test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bandwidth
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: rf_gain
  id: variable
  parameters:
    value: '70'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: tuning
  id: variable
  parameters:
    value: '2200000000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/raghav/sig_ant1
    type: complex
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/raghav/sig_ant2
    type: complex
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: 40*2000000
    type: complex
  states: {}
- name: blocks_head_1
  id: blocks_head
  parameters:
    num_items: 40*2000000
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: bandwidth
    fc: tuning
    fftsize: '32768'
    nconnections: '2'
    type: complex
    update_time: '0.001'
  states: {state: disabled}
- name: uhd_usrp_source_1_0_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    bw0: bandwidth
    bw1: bandwidth
    center_freq0: tuning
    center_freq1: tuning
    clock_rate: '0.0'
    dev_args: '""'
    gain0: rf_gain
    gain1: rf_gain
    nchan: '2'
    rx_agc0: Disabled
    rx_agc1: Disabled
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_head_0, '0', blocks_file_sink_0, '0']
- [blocks_head_1, '0', blocks_file_sink_0_0, '0']
- [uhd_usrp_source_1_0_0, '0', blocks_head_0, '0']
- [uhd_usrp_source_1_0_0, '0', qtgui_waterfall_sink_x_0_0_0, '0']
- [uhd_usrp_source_1_0_0, '1', blocks_head_1, '0']
- [uhd_usrp_source_1_0_0, '1', qtgui_waterfall_sink_x_0_0_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
